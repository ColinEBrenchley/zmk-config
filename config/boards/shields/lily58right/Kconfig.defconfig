## config/boards/shields/lily58right/Kconfig.defconfig
```kconfig
if SHIELD_LILY58RIGHT

config ZMK_KEYBOARD_NAME
    default "lily58right"

endif
```
